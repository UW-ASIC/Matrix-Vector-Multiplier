v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
F {}
E {}
N 70 -400 130 -400 {lab=p0}
N -160 0 550 0 {lab=B0}
N -160 -60 -160 0 {lab=B0}
N -160 -60 -150 -60 {lab=B0}
N -160 120 550 120 {lab=B1}
N -160 60 -160 120 {lab=B1}
N -160 60 -150 60 {lab=B1}
N -160 240 550 240 {lab=B2}
N -160 180 -160 240 {lab=B2}
N -70 180 730 180 {lab=#net1}
N -160 180 -150 180 {lab=B2}
N -160 370 550 370 {lab=B3}
N -160 310 -160 370 {lab=B3}
N -70 310 730 310 {lab=#net2}
N -160 310 -150 310 {lab=B3}
N -160 500 550 500 {lab=B4}
N -160 440 -160 500 {lab=B4}
N -70 440 730 440 {lab=#net3}
N -160 440 -150 440 {lab=B4}
N 550 120 1820 120 {lab=B1}
N 730 180 1820 180 {lab=#net1}
N 550 240 1820 240 {lab=B2}
N 730 310 1810 310 {lab=#net2}
N 550 370 1830 370 {lab=B3}
N 730 440 1820 440 {lab=#net3}
N 550 500 1820 500 {lab=B4}
N 110 -140 110 -60 {lab=#net4}
N 30 -140 30 440 {lab=#net3}
N 50 -140 50 310 {lab=#net2}
N 70 -140 70 180 {lab=#net1}
N 90 -140 90 60 {lab=#net5}
N 290 -400 350 -400 {lab=p1}
N 250 -140 250 440 {lab=#net3}
N 270 -140 270 310 {lab=#net2}
N 290 -140 290 180 {lab=#net1}
N 310 -140 310 60 {lab=#net5}
N 330 -140 330 -0 {lab=B0}
N -170 -570 1800 -570 {lab=VSS}
N -170 -610 1800 -610 {lab=VCC}
N -20 -610 -20 -270 {lab=VCC}
N 160 -570 160 -270 {lab=VSS}
N 200 -610 200 -270 {lab=VCC}
N 380 -570 380 -270 {lab=VSS}
N 510 -400 570 -400 {lab=p2}
N 470 -140 470 440 {lab=#net3}
N 490 -140 490 310 {lab=#net2}
N 510 -140 510 180 {lab=#net1}
N 420 -610 420 -270 {lab=VCC}
N 600 -570 600 -270 {lab=VSS}
N 530 -140 530 120 {lab=B1}
N 550 -140 550 -60 {lab=#net4}
N 730 -400 790 -400 {lab=p3}
N 690 -140 690 440 {lab=#net3}
N 710 -140 710 310 {lab=#net2}
N 770 -140 770 0 {lab=B0}
N 640 -610 640 -270 {lab=VCC}
N 820 -570 820 -270 {lab=VSS}
N -70 -60 1820 -60 {lab=#net4}
N 730 -140 730 180 {lab=#net1}
N 960 -400 1020 -400 {lab=p4}
N 920 -140 920 440 {lab=#net3}
N 940 -140 940 310 {lab=#net2}
N 980 -140 980 60 {lab=#net5}
N 870 -610 870 -270 {lab=VCC}
N 1050 -570 1050 -270 {lab=VSS}
N 750 -140 750 120 {lab=B1}
N 1000 -150 1000 -60 {lab=#net4}
N 960 -140 960 240 {lab=B2}
N 1190 -400 1250 -400 {lab=p5}
N 1150 -140 1150 440 {lab=#net3}
N 1170 -140 1170 310 {lab=#net2}
N 1210 -140 1210 60 {lab=#net5}
N 1100 -610 1100 -270 {lab=VCC}
N 1280 -570 1280 -270 {lab=VSS}
N 1190 -140 1190 240 {lab=B2}
N 1230 -140 1230 -0 {lab=B0}
N 1420 -400 1480 -400 {lab=p6}
N 1380 -140 1380 440 {lab=#net3}
N 1400 -140 1400 310 {lab=#net2}
N 1330 -610 1330 -270 {lab=VCC}
N 1510 -570 1510 -270 {lab=VSS}
N 1420 -140 1420 240 {lab=B2}
N 1460 -140 1460 -60 {lab=#net4}
N 1440 -140 1440 120 {lab=B1}
N 1830 370 3670 370 {lab=B3}
N 1650 -400 1710 -400 {lab=p7}
N 1610 -140 1610 440 {lab=#net3}
N 1630 -140 1630 310 {lab=#net2}
N 1560 -610 1560 -270 {lab=VCC}
N 1740 -570 1740 -270 {lab=VSS}
N 1650 -140 1650 240 {lab=B2}
N 1670 -140 1670 120 {lab=B1}
N 1690 -140 1690 -0 {lab=B0}
N 1800 -610 3700 -610 {lab=VCC}
N 1800 -570 3690 -570 {lab=VSS}
N 1880 -400 1940 -400 {lab=p8}
N 1840 -140 1840 440 {lab=#net3}
N 1790 -610 1790 -270 {lab=VCC}
N 1970 -570 1970 -270 {lab=VSS}
N 2100 -400 2160 -400 {lab=p9}
N 2060 -140 2060 440 {lab=#net3}
N 2010 -610 2010 -270 {lab=VCC}
N 2190 -570 2190 -270 {lab=VSS}
N 2140 -140 2140 0 {lab=B0}
N 550 0 3680 0 {lab=B0}
N 1880 -140 1880 180 {lab=#net1}
N -70 60 3680 60 {lab=#net5}
N 1900 -150 1900 60 {lab=#net5}
N 1920 -140 1920 -60 {lab=#net4}
N 1860 -140 1860 370 {lab=B3}
N 2120 -140 2120 60 {lab=#net5}
N 2100 -140 2100 180 {lab=#net1}
N 2080 -140 2080 370 {lab=B3}
N 2320 -400 2380 -400 {lab=p10}
N 2180 440 2980 440 {lab=#net3}
N 2800 120 4070 120 {lab=B1}
N 2800 240 4070 240 {lab=B2}
N 2980 310 4060 310 {lab=#net2}
N 2980 440 4070 440 {lab=#net3}
N 2800 500 4070 500 {lab=B4}
N 2360 -140 2360 -60 {lab=#net4}
N 2280 -140 2280 440 {lab=#net3}
N 2320 -140 2320 180 {lab=#net1}
N 2540 -400 2600 -400 {lab=p11}
N 2500 -140 2500 440 {lab=#net3}
N 2540 -140 2540 180 {lab=#net1}
N 2230 -610 2230 -270 {lab=VCC}
N 2410 -570 2410 -270 {lab=VSS}
N 2450 -610 2450 -270 {lab=VCC}
N 2630 -570 2630 -270 {lab=VSS}
N 2760 -400 2820 -400 {lab=p12}
N 2720 -140 2720 440 {lab=#net3}
N 2670 -610 2670 -270 {lab=VCC}
N 2850 -570 2850 -270 {lab=VSS}
N 2800 -140 2800 -60 {lab=#net4}
N 2980 -400 3040 -400 {lab=p13}
N 2940 -140 2940 440 {lab=#net3}
N 3020 -140 3020 0 {lab=B0}
N 2890 -610 2890 -270 {lab=VCC}
N 3070 -570 3070 -270 {lab=VSS}
N 2180 -60 4070 -60 {lab=#net4}
N 3210 -400 3270 -400 {lab=p14}
N 3170 -140 3170 440 {lab=#net3}
N 3230 -140 3230 60 {lab=#net5}
N 3120 -610 3120 -270 {lab=VCC}
N 3300 -570 3300 -270 {lab=VSS}
N 3250 -150 3250 -60 {lab=#net4}
N 3210 -140 3210 240 {lab=B2}
N 3440 -400 3500 -400 {lab=p15}
N 3400 -140 3400 440 {lab=#net3}
N 3350 -610 3350 -270 {lab=VCC}
N 3530 -570 3530 -270 {lab=VSS}
N 3440 -140 3440 240 {lab=B2}
N 3480 -140 3480 0 {lab=B0}
N 3670 -400 3730 -400 {lab=p16}
N 3650 -140 3650 310 {lab=#net2}
N 3580 -610 3580 -270 {lab=VCC}
N 3760 -570 3760 -270 {lab=VSS}
N 3710 -140 3710 -60 {lab=#net4}
N 3900 -400 3960 -400 {lab=p17}
N 3880 -140 3880 310 {lab=#net2}
N 3810 -610 3810 -270 {lab=VCC}
N 3990 -570 3990 -270 {lab=VSS}
N 3940 -140 3940 0 {lab=B0}
N 4130 -400 4190 -400 {lab=p18}
N 4040 -610 4040 -270 {lab=VCC}
N 4220 -570 4220 -270 {lab=VSS}
N 4350 -400 4410 -400 {lab=p19}
N 4260 -610 4260 -270 {lab=VCC}
N 4440 -570 4440 -270 {lab=VSS}
N 4130 -140 4130 180 {lab=#net1}
N 4170 -140 4170 -60 {lab=#net4}
N 4350 -140 4350 180 {lab=#net1}
N 1820 -60 2180 -60 {lab=#net4}
N 1820 120 2800 120 {lab=B1}
N 1820 240 2800 240 {lab=B2}
N 1810 310 2980 310 {lab=#net2}
N 1820 440 2180 440 {lab=#net3}
N 1820 500 2800 500 {lab=B4}
N 4070 -60 4580 -60 {lab=#net4}
N 3680 60 4590 60 {lab=#net5}
N 3680 -0 4580 0 {lab=B0}
N 4070 120 4590 120 {lab=B1}
N 4070 180 4590 180 {lab=#net1}
N 4070 240 4590 240 {lab=B2}
N 4060 310 4590 310 {lab=#net2}
N 3670 370 4590 370 {lab=B3}
N 4070 440 4590 440 {lab=#net3}
N 4070 500 4590 500 {lab=B4}
N 3700 -610 4510 -610 {lab=VCC}
N 3690 -570 4510 -570 {lab=VSS}
N 2300 -140 2300 370 {lab=B3}
N 2340 -140 2340 120 {lab=B1}
N 2520 -140 2520 370 {lab=B3}
N 2560 -140 2560 120 {lab=B1}
N 2580 -140 2580 0 {lab=B0}
N 2740 -140 2740 370 {lab=B3}
N 2760 -140 2760 240 {lab=B2}
N 2960 -140 2960 370 {lab=B3}
N 2980 -140 2980 240 {lab=B2}
N 1820 180 4070 180 {lab=#net1}
N 3000 -140 3000 60 {lab=#net5}
N 2780 -140 2780 60 {lab=#net5}
N 3190 -140 3190 370 {lab=B3}
N 3460 -140 3460 120 {lab=B1}
N 3420 -140 3420 370 {lab=B3}
N 3690 -140 3690 60 {lab=#net5}
N 3670 -140 3670 180 {lab=#net1}
N 3630 -140 3630 500 {lab=B4}
N 3860 -140 3860 500 {lab=B4}
N 3920 -140 3920 60 {lab=#net5}
N 3900 -140 3900 180 {lab=#net1}
N 4090 -140 4090 500 {lab=B4}
N 4150 -140 4150 120 {lab=B1}
N 4110 -140 4110 310 {lab=#net2}
N 4330 -140 4330 310 {lab=#net2}
N 4310 -140 4310 500 {lab=B4}
N 4370 -140 4370 120 {lab=B1}
N 4390 -140 4390 0 {lab=B0}
C {5-nand.sym} 70 -290 3 0 {name=x1}
C {opin.sym} 70 -400 3 0 {name=p5 lab=p0}
C {sky130_tests/lvtnot.sym} 130 -440 3 0 {name=x11 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.35 
+ VCCPIN=VCC VSSPIN=VSS}
C {opin.sym} 130 -480 3 0 {name=p7 lab=n0}
C {ipin.sym} -160 0 0 0 {name=p1 lab=B0}
C {sky130_tests/lvtnot.sym} -110 -60 0 0 {name=x6 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.35 
+ VCCPIN=VCC VSSPIN=VSS}
C {ipin.sym} -160 120 0 0 {name=p12 lab=B1}
C {sky130_tests/lvtnot.sym} -110 60 0 0 {name=x12 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.35 
+ VCCPIN=VCC VSSPIN=VSS}
C {ipin.sym} -160 240 0 0 {name=p13 lab=B2}
C {sky130_tests/lvtnot.sym} -110 180 0 0 {name=x13 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.35 
+ VCCPIN=VCC VSSPIN=VSS}
C {ipin.sym} -160 370 0 0 {name=p14 lab=B3}
C {sky130_tests/lvtnot.sym} -110 310 0 0 {name=x14 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.35 
+ VCCPIN=VCC VSSPIN=VSS}
C {ipin.sym} -160 500 0 0 {name=p15 lab=B4}
C {sky130_tests/lvtnot.sym} -110 440 0 0 {name=x15 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.35 
+ VCCPIN=VCC VSSPIN=VSS}
C {5-nand.sym} 290 -290 3 0 {name=x2}
C {opin.sym} 290 -400 3 0 {name=p2 lab=p1}
C {sky130_tests/lvtnot.sym} 350 -440 3 0 {name=x3 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.35 
+ VCCPIN=VCC VSSPIN=VSS}
C {opin.sym} 350 -480 3 0 {name=p3 lab=n1}
C {ipin.sym} -170 -570 0 0 {name=p4 lab=VSS}
C {ipin.sym} -170 -610 0 0 {name=p6 lab=VCC}
C {5-nand.sym} 510 -290 3 0 {name=x4}
C {opin.sym} 510 -400 3 0 {name=p8 lab=p2}
C {sky130_tests/lvtnot.sym} 570 -440 3 0 {name=x5 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.35 
+ VCCPIN=VCC VSSPIN=VSS}
C {opin.sym} 570 -480 3 0 {name=p9 lab=n2}
C {5-nand.sym} 730 -290 3 0 {name=x7}
C {opin.sym} 730 -400 3 0 {name=p10 lab=p3}
C {sky130_tests/lvtnot.sym} 790 -440 3 0 {name=x8 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.35 
+ VCCPIN=VCC VSSPIN=VSS}
C {opin.sym} 790 -480 3 0 {name=p11 lab=n3}
C {5-nand.sym} 960 -290 3 0 {name=x9}
C {opin.sym} 960 -400 3 0 {name=p16 lab=p4}
C {sky130_tests/lvtnot.sym} 1020 -440 3 0 {name=x10 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.35 
+ VCCPIN=VCC VSSPIN=VSS}
C {opin.sym} 1020 -480 3 0 {name=p17 lab=n4}
C {5-nand.sym} 1190 -290 3 0 {name=x16}
C {opin.sym} 1190 -400 3 0 {name=p18 lab=p5}
C {sky130_tests/lvtnot.sym} 1250 -440 3 0 {name=x17 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.35 
+ VCCPIN=VCC VSSPIN=VSS}
C {opin.sym} 1250 -480 3 0 {name=p19 lab=n5}
C {5-nand.sym} 1420 -290 3 0 {name=x18}
C {opin.sym} 1420 -400 3 0 {name=p20 lab=p6}
C {sky130_tests/lvtnot.sym} 1480 -440 3 0 {name=x19 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.35 
+ VCCPIN=VCC VSSPIN=VSS}
C {opin.sym} 1480 -480 3 0 {name=p21 lab=n6}
C {5-nand.sym} 1650 -290 3 0 {name=x20}
C {opin.sym} 1650 -400 3 0 {name=p22 lab=p7}
C {sky130_tests/lvtnot.sym} 1710 -440 3 0 {name=x21 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.35 
+ VCCPIN=VCC VSSPIN=VSS}
C {opin.sym} 1710 -480 3 0 {name=p23 lab=n7}
C {5-nand.sym} 1880 -290 3 0 {name=x22}
C {opin.sym} 1880 -400 3 0 {name=p24 lab=p8}
C {sky130_tests/lvtnot.sym} 1940 -440 3 0 {name=x23 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.35 
+ VCCPIN=VCC VSSPIN=VSS}
C {opin.sym} 1940 -480 3 0 {name=p25 lab=n8}
C {5-nand.sym} 2100 -290 3 0 {name=x24}
C {opin.sym} 2100 -400 3 0 {name=p26 lab=p9}
C {sky130_tests/lvtnot.sym} 2160 -440 3 0 {name=x25 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.35 
+ VCCPIN=VCC VSSPIN=VSS}
C {opin.sym} 2160 -480 3 0 {name=p27 lab=n9}
C {5-nand.sym} 2320 -290 3 0 {name=x26}
C {opin.sym} 2320 -400 3 0 {name=p28 lab=p10}
C {sky130_tests/lvtnot.sym} 2380 -440 3 0 {name=x27 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.35 
+ VCCPIN=VCC VSSPIN=VSS}
C {opin.sym} 2380 -480 3 0 {name=p29 lab=n10}
C {5-nand.sym} 2540 -290 3 0 {name=x28}
C {opin.sym} 2540 -400 3 0 {name=p30 lab=p11}
C {sky130_tests/lvtnot.sym} 2600 -440 3 0 {name=x29 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.35 
+ VCCPIN=VCC VSSPIN=VSS}
C {opin.sym} 2600 -480 3 0 {name=p31 lab=n11}
C {5-nand.sym} 2760 -290 3 0 {name=x30}
C {opin.sym} 2760 -400 3 0 {name=p32 lab=p12}
C {sky130_tests/lvtnot.sym} 2820 -440 3 0 {name=x31 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.35 
+ VCCPIN=VCC VSSPIN=VSS}
C {opin.sym} 2820 -480 3 0 {name=p33 lab=n12}
C {5-nand.sym} 2980 -290 3 0 {name=x32}
C {opin.sym} 2980 -400 3 0 {name=p34 lab=p13}
C {sky130_tests/lvtnot.sym} 3040 -440 3 0 {name=x33 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.35 
+ VCCPIN=VCC VSSPIN=VSS}
C {opin.sym} 3040 -480 3 0 {name=p35 lab=n13}
C {5-nand.sym} 3210 -290 3 0 {name=x34}
C {opin.sym} 3210 -400 3 0 {name=p36 lab=p14}
C {sky130_tests/lvtnot.sym} 3270 -440 3 0 {name=x35 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.35 
+ VCCPIN=VCC VSSPIN=VSS}
C {opin.sym} 3270 -480 3 0 {name=p37 lab=n14}
C {5-nand.sym} 3440 -290 3 0 {name=x36}
C {opin.sym} 3440 -400 3 0 {name=p38 lab=p15}
C {sky130_tests/lvtnot.sym} 3500 -440 3 0 {name=x37 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.35 
+ VCCPIN=VCC VSSPIN=VSS}
C {opin.sym} 3500 -480 3 0 {name=p39 lab=n15}
C {5-nand.sym} 3670 -290 3 0 {name=x38}
C {opin.sym} 3670 -400 3 0 {name=p40 lab=p16}
C {sky130_tests/lvtnot.sym} 3730 -440 3 0 {name=x39 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.35 
+ VCCPIN=VCC VSSPIN=VSS}
C {opin.sym} 3730 -480 3 0 {name=p41 lab=n16}
C {5-nand.sym} 3900 -290 3 0 {name=x40}
C {opin.sym} 3900 -400 3 0 {name=p42 lab=p17}
C {sky130_tests/lvtnot.sym} 3960 -440 3 0 {name=x41 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.35 
+ VCCPIN=VCC VSSPIN=VSS}
C {opin.sym} 3960 -480 3 0 {name=p43 lab=n17}
C {5-nand.sym} 4130 -290 3 0 {name=x42}
C {opin.sym} 4130 -400 3 0 {name=p44 lab=p18}
C {sky130_tests/lvtnot.sym} 4190 -440 3 0 {name=x43 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.35 
+ VCCPIN=VCC VSSPIN=VSS}
C {opin.sym} 4190 -480 3 0 {name=p45 lab=n18}
C {5-nand.sym} 4350 -290 3 0 {name=x44}
C {opin.sym} 4350 -400 3 0 {name=p46 lab=p19}
C {sky130_tests/lvtnot.sym} 4410 -440 3 0 {name=x45 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.35 
+ VCCPIN=VCC VSSPIN=VSS}
C {opin.sym} 4410 -480 3 0 {name=p47 lab=n19}
